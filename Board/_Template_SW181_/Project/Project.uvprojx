# Keil uVision project Project.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SWM181xB Synwit
  pack: Synwit.SWM32_DFP.1.20.4
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x1E000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F30X_HD,__FPU_PRESENT,USE_USBFS,
  c misc: --locale=english
  c include: .\Include;..\Application\ASP;..\Application\ASP\Include;..\Application\BSP;..\Application\BSP\Include;..\LL_Driver\Include;..\LL_Driver\USBD\MSC\Include;..\..\..\F2M_C\Component\Include;..\..\..\F2M_C\Device\Include;..\..\..\F2M_C\Device\DAL\Include;..\..\..\F2M_C\FWAL\Include;..\..\..\F2M_C\FWAL\HAL\Include;..\..\..\F2M_C\Library\Include;..\..\..\F2M_C\Protocol\Include;..\..\..\Firmware\SWM181\SWM181_StdPeriph_Driver;..\..\..\Firmware\SWM181\CMSIS\CoreSupport;..\..\..\Firmware\SWM181\CMSIS\DeviceSupport;..\..\..\Third_Party\LVGL\src;..\..\..\Third_Party\LVGL\src\core;..\..\..\Third_Party\LVGL\src\draw;..\..\..\Third_Party\LVGL\src\extra;..\..\..\Third_Party\LVGL\src\font;..\..\..\Third_Party\LVGL\src\gpu;..\..\..\Third_Party\LVGL\src\hal;..\..\..\Third_Party\LVGL\src\misc;..\..\..\Third_Party\LVGL\src\widgets;..\Ports\LVGL;..\Application\UI\custom;..\Application\UI\generated;..\Application\UI\generated\guider_customer_fonts;..\Application\UI\generated\guider_fonts;..\..\..\Third_Party\cJSON;..\Ports\fatfs;..\..\..\Third_Party\fatfs\source;..\..\..\Third_Party\littlefs;..\Ports\littlefs
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1e000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Document
    ../../../Document/: 1、错误、警告修复记录.txt 2、调试、修改记录.txt
  group Project
    ./Include/: project_config.h project_debug.h project_mod_conf.h
  group Application
    ../Application/: main.c
  group ——Task
    ../Application/Task/: main_task.c
  group LL_Driver
    ../LL_Driver/Source/: ll_system.c ll_delay.c ll_gpio.c ll_exti.c ll_uart.c ll_flash.c ll_rtc.c ll_wdg.c ll_s2ram.c ll_bkp.c ll_bus.c ll_adc.c ll_timer.c ll_spi.c
  group ——Startup
    ../LL_Driver/Startup/: startup_SWM181.s
  group ——FatFS
    ../Ports/fatfs/: diskio.c diskio.h ffconf.h
  group ——LittleFS
    ../Ports/littlefs/: lfs_port.c lfs_conf.h
  group Component
    ../../../F2M_C/Component/Source/: mm.c stiming.c time.c mblock.c rbuffer.c serial.c event.c
  group Device
    ../../../F2M_C/Device/Source/: io_encoder.c ili9341.c gd25q64.c wf200d.c wf183d.c esp8266.c fm17522.c ds18b20.c st7735.c gyy0709.c tm7711.c hc595.c
  group ——DAL
    ../../../F2M_C/Device/DAL/Source/: key.c led.c mifare.c qencoder.c lcd.c sensor.c wifi.c
  group FWAL
    ../../../F2M_C/FWAL/Source/: fw_device.c fw_driver.c fw_print.c fw_startup.c
    ../../../F2M_C/FWAL/Include/: fw_config.h fw_debug.h
  group ——HAL
    ../../../F2M_C/FWAL/HAL/Source/: fw_system.c fw_delay.c fw_gpio.c fw_adc.c fw_bkp.c fw_exti.c fw_os.c fw_pwr.c fw_uart.c fw_suart.c fw_usb.c fw_flash.c fw_rtc.c fw_wdg.c fw_s2ram.c fw_bus.c fw_spi.c fw_sspi.c fw_i2c.c fw_si2c.c fw_timer.c fw_sbus.c fw_ow.c fw_dac.c fw_can.c
  group Library
    ../../../F2M_C/Library/Source/: lib_bsc.c lib_int.c lib_string.c lib_ctrl.c
  group Protocol
    ../../../F2M_C/Protocol/Source/: smodem_master.c smodem_slave.c
  group SWM181_StdPeriph_Driver
    ../../../Firmware/SWM181/SWM181_StdPeriph_Driver/: SWM181_adc.c SWM181_cache.c SWM181_can.c SWM181_cmp.c SWM181_cordic.c SWM181_div.c SWM181_dma.c SWM181_exti.c SWM181_flash.c SWM181_gpio.c SWM181_i2c.c SWM181_irqmux.c SWM181_port.c SWM181_pwm.c SWM181_sdadc.c SWM181_slcd.c SWM181_sleep.c SWM181_spi.c SWM181_timr.c SWM181_uart.c SWM181_wdt.c system_SWM181.c
  group FatFS
    ../../../Third_Party/fatfs/source/: ff.c ff.h ffsystem.c ffunicode.c
  group LittleFS
    ../../../Third_Party/littlefs/: lfs.h lfs_util.h lfs.c lfs_util.c
  group cJSON
    ../../../Third_Party/cJSON/: cJSON.c
