# Keil uVision project Project.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F435VMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.9
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x3F0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --locale=english
  c include: .\Include;..\Application\ASP;..\Application\ASP\Include;..\Application\BSP;..\Application\BSP\Include;..\LL_Driver\Include;..\LL_Driver\USBD\MSC\Include;..\..\..\F2M_C\Component\Include;..\..\..\F2M_C\Device\Include;..\..\..\F2M_C\Device\DAL\Include;..\..\..\F2M_C\FWAL\Include;..\..\..\F2M_C\FWAL\HAL\Include;..\..\..\F2M_C\Library\Include;..\..\..\F2M_C\Protocol\Include;..\..\..\Firmware\GD32F30x_Firmware_Library\CMSIS;..\..\..\Firmware\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include;..\..\..\Firmware\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include;..\..\..\Firmware\GD32F30x_Firmware_Library\GD32F30x_usbd_driver\Include;..\..\..\Third_Party\LVGL\src;..\..\..\Third_Party\LVGL\src\core;..\..\..\Third_Party\LVGL\src\draw;..\..\..\Third_Party\LVGL\src\extra;..\..\..\Third_Party\LVGL\src\font;..\..\..\Third_Party\LVGL\src\gpu;..\..\..\Third_Party\LVGL\src\hal;..\..\..\Third_Party\LVGL\src\misc;..\..\..\Third_Party\LVGL\src\widgets;..\Ports\LVGL;..\Application\UI\custom;..\Application\UI\generated;..\Application\UI\generated\guider_customer_fonts;..\Application\UI\generated\guider_fonts;..\..\..\Third_Party\cJSON;..\Ports\fatfs;..\..\..\Third_Party\fatfs\source;..\..\..\Third_Party\littlefs;..\Ports\littlefs;..\..\..\Firmware\AT32F435_437_Firmware_Library\libraries\cmsis\cm4\core_support;..\..\..\Firmware\AT32F435_437_Firmware_Library\libraries\cmsis\cm4\device_support;..\..\..\Firmware\AT32F435_437_Firmware_Library\libraries\drivers\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group Document
    ../../../Document/: 1、错误、警告修复记录.txt 2、调试、修改记录.txt
  group Project
    ./Include/: project_config.h project_debug.h
  group Application
    ../Application/: main.c
  group LL_Driver
    ../LL_Driver/Source/: ll_system.c ll_delay.c ll_gpio.c ll_flash.c ll_uart.c
  group ——Startup
    ../LL_Driver/Startup/: startup_at32f435_437.s
  group Component
    ../../../F2M_C/Component/Source/: mblock.c mm.c rbuffer.c serial.c stiming.c time.c event.c monitor.c queue.c
  group FWAL
    ../../../F2M_C/FWAL/Source/: fw_device.c fw_driver.c fw_print.c fw_startup.c
  group ——HAL
    ../../../F2M_C/FWAL/HAL/Source/: fw_system.c fw_delay.c fw_gpio.c fw_adc.c fw_bkp.c fw_bus.c fw_dac.c fw_exti.c fw_flash.c fw_i2c.c fw_led.c fw_os.c fw_ow.c fw_pwm.c fw_pwr.c fw_rtc.c fw_s2ram.c fw_sbus.c fw_si2c.c fw_spi.c fw_sspi.c fw_suart.c fw_timer.c fw_uart.c fw_usb.c fw_wdg.c
  group CMSIS
    ../../../Firmware/AT32F435_437_Firmware_Library/libraries/cmsis/cm4/device_support/: system_at32f435_437.c
  group AT32F435_437_Firmware_Library
    ../../../Firmware/AT32F435_437_Firmware_Library/libraries/drivers/src/: at32f435_437_acc.c at32f435_437_adc.c at32f435_437_can.c at32f435_437_crc.c at32f435_437_crm.c at32f435_437_dac.c at32f435_437_debug.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_ertc.c at32f435_437_exint.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_qspi.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_usb.c at32f435_437_wdt.c at32f435_437_wwdt.c at32f435_437_xmc.c
