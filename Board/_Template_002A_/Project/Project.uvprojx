# Keil uVision project Project.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F002Ax5 Puya
  pack: Puya.PY32F0xx_DFP.1.1.7
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F002Ax5, USE_FULL_LL_DRIVER
  c misc: --locale=english
  c include: .\Include;..\Application\ASP;..\Application\ASP\Include;..\Application\BSP;..\Application\BSP\Include;..\LL_Driver\Include;..\LL_Driver\USBD\MSC\Include;..\..\..\F2M_C\Component\Include;..\..\..\F2M_C\Device\Include;..\..\..\F2M_C\Device\DAL\Include;..\..\..\F2M_C\FWAL\Include;..\..\..\F2M_C\FWAL\HAL\Include;..\..\..\F2M_C\Library\Include;..\..\..\F2M_C\Protocol\Include;..\..\..\Firmware\PY32F0xx_Firmware_Library\CMSIS\Include;..\..\..\Firmware\PY32F0xx_Firmware_Library\CMSIS\Device\PY32F0xx\Include;..\..\..\Firmware\PY32F0xx_Firmware_Library\PY32F0xx_HAL_Driver\Inc;..\..\..\Third_Party\LVGL\src;..\..\..\Third_Party\LVGL\src\core;..\..\..\Third_Party\LVGL\src\draw;..\..\..\Third_Party\LVGL\src\extra;..\..\..\Third_Party\LVGL\src\font;..\..\..\Third_Party\LVGL\src\gpu;..\..\..\Third_Party\LVGL\src\hal;..\..\..\Third_Party\LVGL\src\misc;..\..\..\Third_Party\LVGL\src\widgets;..\Ports\LVGL;..\Application\UI\custom;..\Application\UI\generated;..\Application\UI\generated\guider_customer_fonts;..\Application\UI\generated\guider_fonts;..\..\..\Third_Party\cJSON;..\Ports\fatfs;..\..\..\Third_Party\fatfs\source;..\..\..\Third_Party\littlefs;..\Ports\littlefs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Document
    ../../../Document/: 1、错误、警告修复记录.txt 2、调试、修改记录.txt
  group Project
    ./Include/: project_config.h project_debug.h
  group Application
    ../Application/: main.c
  group ——Task
    ../Application/Task/: main_task.c
  group LL_Driver
    ../LL_Driver/Source/: ll_system.c ll_delay.c ll_gpio.c ll_uart.c ll_exti.c ll_flash.c ll_wdg.c ll_s2ram.c ll_adc.c ll_timer.c ll_spi.c ll_pmu.c ll_i2c.c
  group ——Startup
    ../LL_Driver/Startup/: startup_py32f002xx.s
  group Component
    ../../../F2M_C/Component/Source/: mm.c stiming.c time.c mblock.c rbuffer.c serial.c event.c
  group Device
    ../../../F2M_C/Device/Source/: hc595.c
  group ——DAL
    ../../../F2M_C/Device/DAL/Source/: key.c led.c mifare.c qencoder.c lcd.c sensor.c pwm.c wifi.c
  group FWAL
    ../../../F2M_C/FWAL/Source/: fw_device.c fw_driver.c fw_print.c fw_startup.c
    ../../../F2M_C/FWAL/Include/: fw_config.h fw_debug.h
  group ——HAL
    ../../../F2M_C/FWAL/HAL/Source/: fw_system.c fw_delay.c fw_gpio.c fw_adc.c fw_bkp.c fw_exti.c fw_os.c fw_pwr.c fw_uart.c fw_suart.c fw_flash.c fw_wdg.c fw_s2ram.c fw_spi.c fw_sspi.c fw_i2c.c fw_si2c.c fw_timer.c fw_sbus.c fw_ow.c
  group Library
    ../../../F2M_C/Library/Source/: lib_bsc.c lib_int.c lib_string.c lib_ctrl.c
  group Protocol
    ../../../F2M_C/Protocol/Source/: smodem_master.c smodem_slave.c
  group PY32F0xx_HAL_Driver
    ../../../Firmware/PY32F0xx_Firmware_Library/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal_cortex.c py32f0xx_hal_flash.c py32f0xx_it.c py32f0xx_ll_adc.c py32f0xx_ll_comp.c py32f0xx_ll_crc.c py32f0xx_ll_dma.c py32f0xx_ll_exti.c py32f0xx_ll_gpio.c py32f0xx_ll_i2c.c py32f0xx_ll_led.c py32f0xx_ll_lptim.c py32f0xx_ll_pwr.c py32f0xx_ll_rcc.c py32f0xx_ll_rtc.c py32f0xx_ll_spi.c py32f0xx_ll_tim.c py32f0xx_ll_usart.c py32f0xx_ll_utils.c system_py32f0xx.c
