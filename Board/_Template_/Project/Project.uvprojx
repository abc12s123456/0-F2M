# Keil uVision project Project.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F30X_HD,__FPU_PRESENT,USE_USBFS,
  c misc: --locale=english
  c include: .\Include;..\Application\ASP;..\Application\ASP\Include;..\Application\BSP;..\Application\BSP\Include;..\LL_Driver\Include;..\LL_Driver\USBD\MSC\Include;..\..\..\F2M_C\Component\Include;..\..\..\F2M_C\Device\Include;..\..\..\F2M_C\Device\DAL\Include;..\..\..\F2M_C\FWAL\Include;..\..\..\F2M_C\FWAL\HAL\Include;..\..\..\F2M_C\Library\Include;..\..\..\F2M_C\Protocol\Include;..\..\..\Firmware\GD32F30x_Firmware_Library\CMSIS;..\..\..\Firmware\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include;..\..\..\Firmware\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include;..\..\..\Firmware\GD32F30x_Firmware_Library\GD32F30x_usbd_driver\Include;..\..\..\Third_Party\LVGL\src;..\..\..\Third_Party\LVGL\src\core;..\..\..\Third_Party\LVGL\src\draw;..\..\..\Third_Party\LVGL\src\extra;..\..\..\Third_Party\LVGL\src\font;..\..\..\Third_Party\LVGL\src\gpu;..\..\..\Third_Party\LVGL\src\hal;..\..\..\Third_Party\LVGL\src\misc;..\..\..\Third_Party\LVGL\src\widgets;..\Ports\LVGL;..\Application\UI\custom;..\Application\UI\generated;..\Application\UI\generated\guider_customer_fonts;..\Application\UI\generated\guider_fonts;..\..\..\Third_Party\cJSON;..\Ports\fatfs;..\..\..\Third_Party\fatfs\source;..\..\..\Third_Party\littlefs;..\Ports\littlefs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Document
    ../../../Document/: 1、错误、警告修复记录.txt 2、调试、修改记录.txt
  group Project
    ./Include/: project_config.h project_debug.h project_mod_conf.h
  group Application
    ../Application/: main.c
  group ——Task
    ../Application/Task/: main_task.c
  group LL_Driver
    ../LL_Driver/Source/: ll_system.c ll_delay.c ll_gpio.c ll_exti.c ll_uart.c ll_flash.c ll_rtc.c ll_wdg.c ll_s2ram.c ll_bkp.c ll_usb.c ll_bus.c ll_adc.c ll_timer.c ll_spi.c ll_dac.c ll_can.c
  group ——Startup
    ../LL_Driver/Startup/: startup_gd32f30x_hd.s
  group ——USBD_MSC
    ../LL_Driver/USBD/MSC/Source/: bbb_scsi_driver.c flash_access.c msc_core.c
    ../LL_Driver/USBD/MSC/Include/: usbd_conf.h
  group ——FatFS
    ../Ports/fatfs/: diskio.c diskio.h ffconf.h
  group ——LittleFS
    ../Ports/littlefs/: lfs_port.c lfs_conf.h
  group ——LVGL
    ../Ports/LVGL/: lv_conf.h lv_port_disp.c lv_port_disp.h lv_port_fs.c lv_port_fs.h lv_port_indev.c lv_port_indev.h
  group Component
    ../../../F2M_C/Component/Source/: mm.c stiming.c time.c mblock.c rbuffer.c serial.c event.c
  group Device
    ../../../F2M_C/Device/Source/: io_encoder.c ili9341.c gd25q64.c wf200d.c wf183d.c esp8266.c fm17522.c ds18b20.c st7735.c gyy0709.c tm7711.c hc595.c
  group ——DAL
    ../../../F2M_C/Device/DAL/Source/: key.c led.c mifare.c qencoder.c lcd.c sensor.c pwm.c wifi.c
  group FWAL
    ../../../F2M_C/FWAL/Source/: fw_device.c fw_driver.c fw_print.c fw_startup.c
    ../../../F2M_C/FWAL/Include/: fw_config.h fw_debug.h
  group ——HAL
    ../../../F2M_C/FWAL/HAL/Source/: fw_system.c fw_delay.c fw_gpio.c fw_adc.c fw_bkp.c fw_exti.c fw_os.c fw_pwr.c fw_uart.c fw_suart.c fw_usb.c fw_flash.c fw_rtc.c fw_wdg.c fw_s2ram.c fw_bus.c fw_spi.c fw_sspi.c fw_i2c.c fw_si2c.c fw_timer.c fw_sbus.c fw_ow.c fw_dac.c fw_can.c
  group Library
    ../../../F2M_C/Library/Source/: lib_bsc.c lib_int.c lib_string.c lib_ctrl.c lib_crc.c
  group Protocol
    ../../../F2M_C/Protocol/Source/: smodem_master.c smodem_slave.c
  group CMSIS
    ../../../Firmware/GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group GD32F30x_standard_peripheral
    ../../../Firmware/GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_it.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group GD32F30x_usbd_library
    ../../../Firmware/GD32F30x_Firmware_Library/GD32F30x_usbd_driver/Source/: usbd_core.c usbd_int.c usbd_pwr.c usbd_std.c
  group FatFS
    ../../../Third_Party/fatfs/source/: ff.c ff.h ffsystem.c ffunicode.c
  group LittleFS
    ../../../Third_Party/littlefs/: lfs.h lfs_util.h lfs.c lfs_util.c
  group ——lv_core
    ../../../Third_Party/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group ——lv_draw
    ../../../Third_Party/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../../Third_Party/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group ——lv_extra
    ../../../Third_Party/LVGL/src/extra/: lv_extra.c
    ../../../Third_Party/LVGL/src/extra/layouts/flex/: lv_flex.c
    ../../../Third_Party/LVGL/src/extra/layouts/grid/: lv_grid.c
    ../../../Third_Party/LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../../../Third_Party/LVGL/src/extra/themes/default/: lv_theme_default.c
    ../../../Third_Party/LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../../../Third_Party/LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../../../Third_Party/LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../Third_Party/LVGL/src/extra/widgets/chart/: lv_chart.c
    ../../../Third_Party/LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../../Third_Party/LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../../Third_Party/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../../Third_Party/LVGL/src/extra/widgets/led/: lv_led.c
    ../../../Third_Party/LVGL/src/extra/widgets/list/: lv_list.c
    ../../../Third_Party/LVGL/src/extra/widgets/menu/: lv_menu.c
    ../../../Third_Party/LVGL/src/extra/widgets/meter/: lv_meter.c
    ../../../Third_Party/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../../Third_Party/LVGL/src/extra/widgets/span/: lv_span.c
    ../../../Third_Party/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../../Third_Party/LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../../../Third_Party/LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../../../Third_Party/LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../../../Third_Party/LVGL/src/extra/widgets/win/: lv_win.c
  group ————lv_libs
    ../../../Third_Party/LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ../../../Third_Party/LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c
    ../../../Third_Party/LVGL/src/extra/libs/bmp/: lv_bmp.c lv_bmp.h
  group ——lv_font
    ../../../Third_Party/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c font_hczk_16.c font_alphc_16.c
  group ——lv_hal
    ../../../Third_Party/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group ——lv_misc
    ../../../Third_Party/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group ——lv_widgets
    ../../../Third_Party/LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group cJSON
    ../../../Third_Party/cJSON/: cJSON.c
