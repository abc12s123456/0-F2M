# IAR project freertos_demo.ewp, settings and files
configuration at_start_f403a (ARM, debug)
  General.OGChipSelectEditMenu: AT32F403AVGT7 ArteryTek AT32F403AVGT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT_START_F403A_V1; AT32F403AVGT7
  ICCARM.CCIncludePath2: ..\..\..\libraries\drivers\inc; ..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\libraries\cmsis\cm4\device_support; ..\..\..\middlewares\freertos\source\include; ..\..\..\middlewares\freertos\source\portable\IAR\ARM_CM4F; ..\inc; ..\..\..\project\at32f403a_407_board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\middlewares\freertos\source\portable\IAR\ARM_CM4F; ..\inc
  OBJCOPY.OOCOutputFile: freertos_demo.hex
  ILINK.IlinkOutputFile: freertos_demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration at_start_f407 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F407VGT7 ArteryTek AT32F407VGT7
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT_START_F407_V1; AT32F407VGT7
  group bsp
    ../../../project/at32f403a_407_board/: at32f403a_407_board.c
  group cmsis
    ../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f403a_407.s
    ../../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group firmware
    ../../../libraries/drivers/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group freertos
    ../../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../middlewares/freertos/source/portable/memmang/: heap_4.c
    ../../../middlewares/freertos/source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group readme
    ../: readme.txt
  group user
    ../src/: at32f403a_407_clock.c at32f403a_407_int.c main.c
